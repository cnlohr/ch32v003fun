# Keil uVision project NHC-Link042.uvprojx, settings and files
target NHC-Link042 (5060960::V5.06 update 7 (build 960)::.\v6)
  device: STM32F042F6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x1800) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: NHC-Link042 +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F042, INTERNAL_PULLUP, USB_CLOCK_SOURCE_CRS
  c include: .\User;.\STM32F0x2_USB-FS-Device_Lib_V1.0.0\Libraries\CMSIS\Device\ST\STM32F0xx\Include;.\STM32F0x2_USB-FS-Device_Lib_V1.0.0\Libraries\STM32F0xx_StdPeriph_Driver\inc;.\STM32F0x2_USB-FS-Device_Lib_V1.0.0\Libraries\STM32_USB_Device_Driver\inc;.\STM32F0x2_USB-FS-Device_Lib_V1.0.0\Libraries\STM32_USB_Device_Library\Core\inc;.\LibUSB;.\STM32F0x2_USB-FS-Device_Lib_V1.0.0\Libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./User/: it.c main.c usb_bsp.c usbd_pwr.c usbd_desc.c usbd_usr.c stm32_it.c NHC_WCH_SDI.c NHC_WCH_SDI.h config.h usbd_desc.h
  group USB_Class
    ./LibUSB/: LibUSB.c
  group CMSIS
    ./User/: system_stm32f0xx.c
    ./STM32F0x2_USB-FS-Device_Lib_V1.0.0/Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f042.s
  group LIB
    ./STM32F0x2_USB-FS-Device_Lib_V1.0.0/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_crs.c stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_misc.c
  group USB_Lib
    ./STM32F0x2_USB-FS-Device_Lib_V1.0.0/Libraries/STM32_USB_Device_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
    ./STM32F0x2_USB-FS-Device_Lib_V1.0.0/Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
